Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: 20251026 - foreignobject svg.ifc
Time: 2025-10-26T12:47:21-05:00
Written by: IfcOpenShell 0.0.0
Made in: Bonsai 0.8.4-alpha251023-5dbfe53
Authorization: Nobody

# IfcProject, My Project
Document: UNTITLED; DESIGN CRITERIA
